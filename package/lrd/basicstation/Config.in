## package/lrd/basicstation/Config.in
```kconfig
config BR2_PACKAGE_BASICSTATION
	bool "basicstation"
	select BR2_PACKAGE_MBEDTLS
	help
      Semtech - Basic Station
```
